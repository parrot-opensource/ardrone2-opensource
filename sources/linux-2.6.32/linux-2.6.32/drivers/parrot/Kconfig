## sources/linux-2.6.32/linux-2.6.32/drivers/parrot/Kconfig
```kconfig
menu "Parrot drivers"
source "drivers/parrot/char/Kconfig"
source "drivers/parrot/usb/otg/Kconfig"
endmenu
```
